# Keil uVision project Controller_of_Mars_Exploration.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Controller_of_Mars_Exploration +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\USER;.\FWlib\src;.\FWlib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ./CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group USER
    ./USER/: stm32f10x_conf.h delay.c controller.c main.c usart1.c stm32f10x_it.c movement.c
  group FWlib
    ./FWlib/src/: stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_rcc.c stm32f10x_tim.c
